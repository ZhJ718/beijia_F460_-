# Keil uVision project TouKui_F403A_V0610A_App.uvprojx, settings and files
target App (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ARGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App_DB_TK_F403A_V6_0_0 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output "..\..\..\output\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ARGT7,USE_STDPERIPH_DRIVER,_APP
  c include: ..\..\..\board\AT32F403A\config;..\..\..\board;..\..\..\drivers;..\..\..\device;..\..\..\workbench;..\..\..\config;..\..\..\board\AT32F403A\core;..\..\..\board\AT32F403A\inc;..\..\..\board\AT32F403A\src;..\..\AT32F403A;..\..\..\include
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: main.c zigcom_task.c gpscom_task.c lasercom_task.c rescom_task.c battery_task.c ir38com_task.c
    ../../: main_task.c upgrade.c
  group CORE
    ../../../board/AT32F403A/core/: core_cm4.h startup_at32f403argt7.s
    ../../../board/AT32F403A/config/: system_at32f4xx.c at32f4xx_conf.h at32f4xx.h
  group FWLIB
    ../../../board/AT32F403A/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group CONFIG
    ../../../config/: config.h
  group DRIVER
    ../../../drivers/: timer.c uart.c malloc.c gpio.c iflash.c iwdt.c drv_config.h spi.c adc.c
  group DEVICES
    ../../../device/: led.c motor.c beep.c w25qxx.c extflash.c new_zigbee.c gps.c fume.c wtn6.c lasercom.c IR.c
    ../../: update_com.c
  group COMMON
    ../../../include/: protocal.c linkqueue.c linklist.c sort.c
    ../../: metadata.h
