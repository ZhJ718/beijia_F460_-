# Keil uVision project Beijia_F460_Boot.uvprojx, settings and files
target Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Boot_DB_BJ_F460_V6_4_0_20230830_1 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output "..\..\..\output\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c include: ..\..\..\board\HC32F460\config;..\..\..\board\HC32F460\core;..\..\..\board\HC32F460\inc;..\..\..\config;..\..\..\drivers;..\Boot;..\..\..\device;..\..\..\include;..\..\..\workbench;.\Code
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group USER
    ./Code/: main.c ddl_config.h zigcom_task.c upcom_task.c
    ../../: main_task.c upgrade.c update_com.c comtask.c param.c
  group CORE
    ../../../board/HC32F460/core/: startup_hc32f46x.s core_cm4.h
    ../../../board/HC32F460/config/: system_hc32f46x.c hc32f46x.h
  group FWLIB
    ../../../board/HC32F460/src/: hc32f46x_adc.c hc32f46x_clk.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_gpio.c hc32f46x_pwc.c hc32f46x_rtc.c hc32f46x_spi.c hc32f46x_timer0.c hc32f46x_timera.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c hc32f46x_timer4_cnt.c hc32f46x_icg.c
  group CONFIG
    ../../../config/: config.h
  group DRIVER
    ../../../drivers/: timer.c uart.c malloc.c gpio.c iflash.c iwdt.c drv_config.h spi.c queue.c
  group DEVICES
    ../../../device/: led.c beep.c motor.c w25qxx.c new_zigbee.c extflash.c
  group COMMON
    ../../../include/: protocal.c linkqueue.c linklist.c
    ../../: metadata.h
