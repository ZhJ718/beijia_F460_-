/******************************************************************
*版权所有 (C)2023,江苏华如防务科技有限公司
*
*文件名称:  sort.c
*文件标识:
*内容摘要:
*其它说明:
*当前版本:
*作    者: 
*完成日期:  2023/4/11
*
*修改记录1:
*    修改日期:
*    版 本 号:
*    修 改 人:xfw
*    修改内容:
******************************************************************/

/******************************************************************
*                             头文件                              *
******************************************************************/
#include "sort.h"

/******************************************************************
*                           全局变量声明                          *
******************************************************************/


/*************************************************************************************************************************************************************************
 * 函数
 ************************************************************************************************************************************************************************
 */

/****************************************************************
@FUNCTION：冒泡排序，针对U16数据类型
@INPUT：
@OUTPUT：
@RETURN:
@AUTHOR：
@SPECIAL:
****************************************************************/
extern void Bubble_Sort_U16(uint16_t *a,uint16_t n)
{
	uint16_t i,j;
	uint16_t t;
	
		
	for(i=1;i<=n-1;i++) //n个数排序，只用进行n-1趟
	{
		for(j=1;j<=n-i;j++) //从第1位开始比较直到最后一个尚未归位的数
		{
			if(a[j]<a[j+1]) //比较大小并交换
			{ 
				t=a[j]; a[j]=a[j+1]; a[j+1]=t; 
			}
		}
	}
}

/****************************************************************
@FUNCTION：选择法排序，针对U16数据类型
@INPUT：
@OUTPUT：
@RETURN:
@AUTHOR：
@SPECIAL:
****************************************************************/
extern void Choose_Sort_U16(uint16_t *unsorted,uint32_t len)
{
    uint32_t i,j;
	uint32_t temp;
    
    for (i = 0; i < len; i++)
    {
        for (j = i; j < len; j++)
        {
            if (unsorted[i] > unsorted[j])
            {
                temp = unsorted[i];
                unsorted[i] = unsorted[j];
                unsorted[j] = temp;
            }
        }
    }
}

